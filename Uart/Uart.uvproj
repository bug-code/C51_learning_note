# Keil uVision project Uart.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Uart +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.h interrupt_utils.h Uart_Init.h Scan_Button.h main.c
