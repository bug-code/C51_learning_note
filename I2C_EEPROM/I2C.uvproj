# Keil uVision project I2C.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: I2C +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App\24c02;.\App\iic;.\App\key;.\App\smg;.\Public;.\App\func_test
  group App
    ./App/key/: Individual_keys.c
    ./App/smg/: digit_display.c
    ./App/iic/: IIC.c
    ./App/24c02/: 24c02.c
    ./App/func_test/: func_test.c
  group User
    ./User/: main.c
  group Public
    ./Public/: delay.c public.h
