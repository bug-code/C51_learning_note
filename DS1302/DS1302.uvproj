# Keil uVision project DS1302.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DS1302
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public;.\User;.\App\DS1302;.\App\key;.\App\SMG
  group App
    ./App/key/: Individual_keys.c Individual_keys.h
    ./App/SMG/: digit_display.c digit_display.h
    ./App/DS1302/: DS1302.h DS1302.c
  group Public
    ./Public/: Public.h delay.c delay.h BCD_to_decimal.h BCD_to_decimal.c
