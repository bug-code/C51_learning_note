# Keil uVision project interrupt.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: interrupt +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: interrupt_utils.h Inter0.c Digit_utils.h StopWatch.h
